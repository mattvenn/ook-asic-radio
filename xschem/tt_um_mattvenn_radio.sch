v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {tt_um_mattvenn_radio: radio_analog + radio_digital (hardened macro) on the TT pins
ua[0]/ua[1] RX dipole, ua[2] debug (det, dbg_en only), ua[3]/ua[4] TX dipole} -900 -760 0 0 0.4 0.4 {}
C {devices/iopin.sym} -900 -660 0 0 {name=p1
lab=VGND}
C {devices/iopin.sym} -900 -630 0 0 {name=p2
lab=VDPWR}
C {devices/iopin.sym} -900 -600 0 0 {name=p3
lab=VAPWR}
C {devices/iopin.sym} -900 -570 0 0 {name=p4
lab=ui_in[7:0]}
C {devices/iopin.sym} -900 -540 0 0 {name=p5
lab=uo_out[7:0]}
C {devices/iopin.sym} -900 -510 0 0 {name=p6
lab=uio_in[7:0]}
C {devices/iopin.sym} -900 -480 0 0 {name=p7
lab=uio_out[7:0]}
C {devices/iopin.sym} -900 -450 0 0 {name=p8
lab=uio_oe[7:0]}
C {devices/iopin.sym} -900 -420 0 0 {name=p9
lab=ua[7:0]}
C {devices/iopin.sym} -900 -390 0 0 {name=p10
lab=ena}
C {devices/iopin.sym} -900 -360 0 0 {name=p11
lab=clk}
C {devices/iopin.sym} -900 -330 0 0 {name=p12
lab=rst_n}
C {radio_digital.sym} -300 0 0 0 {name=xdig}
C {devices/lab_pin.sym} -440 -180 0 0 {name=p13
sig_type=std_logic
lab=clk}
C {devices/lab_pin.sym} -440 -140 0 0 {name=p14
sig_type=std_logic
lab=rst_n}
C {devices/lab_pin.sym} -440 -100 0 0 {name=p15
sig_type=std_logic
lab=ui_in[7:0]}
C {devices/lab_pin.sym} -440 -60 0 0 {name=p16
sig_type=std_logic
lab=uio_in[7:0]}
C {devices/lab_pin.sym} -160 -180 0 1 {name=p17
sig_type=std_logic
lab=uo_out[7:0]}
C {devices/lab_pin.sym} -160 -140 0 1 {name=p18
sig_type=std_logic
lab=uio_out[7:0]}
C {devices/lab_pin.sym} -160 -100 0 1 {name=p19
sig_type=std_logic
lab=uio_oe[7:0]}
C {devices/lab_pin.sym} -160 -60 0 1 {name=p20
sig_type=std_logic
lab=trim[7:0]}
C {devices/lab_pin.sym} -440 -20 0 0 {name=p21
sig_type=std_logic
lab=comp}
C {devices/lab_pin.sym} -160 -20 0 1 {name=p22
sig_type=std_logic
lab=tx_en}
C {devices/lab_pin.sym} -160 20 0 1 {name=p23
sig_type=std_logic
lab=tx_en_n}
C {devices/lab_pin.sym} -160 60 0 1 {name=p24
sig_type=std_logic
lab=rx_en}
C {devices/lab_pin.sym} -160 100 0 1 {name=p25
sig_type=std_logic
lab=dbg_en}
C {devices/lab_pin.sym} -160 140 0 1 {name=p26
sig_type=std_logic
lab=sc_phi1}
C {devices/lab_pin.sym} -160 180 0 1 {name=p27
sig_type=std_logic
lab=sc_phi2}
C {devices/lab_pin.sym} -390 -230 0 0 {name=p28
sig_type=std_logic
lab=VDPWR}
C {devices/lab_pin.sym} -390 230 0 0 {name=p29
sig_type=std_logic
lab=VGND}
C {radio_analog.sym} 400 0 0 0 {name=xana}
C {devices/lab_pin.sym} 260 -120 0 0 {name=p30
sig_type=std_logic
lab=rx_en}
C {devices/lab_pin.sym} 260 -80 0 0 {name=p31
sig_type=std_logic
lab=tx_en}
C {devices/lab_pin.sym} 260 -40 0 0 {name=p32
sig_type=std_logic
lab=tx_en_n}
C {devices/lab_pin.sym} 260 0 0 0 {name=p33
sig_type=std_logic
lab=dbg_en}
C {devices/lab_pin.sym} 260 40 0 0 {name=p34
sig_type=std_logic
lab=sc_phi1}
C {devices/lab_pin.sym} 260 80 0 0 {name=p35
sig_type=std_logic
lab=sc_phi2}
C {devices/lab_pin.sym} 540 -120 0 1 {name=p36
sig_type=std_logic
lab=comp}
C {devices/lab_pin.sym} 310 -170 0 0 {name=p37
sig_type=std_logic
lab=VDPWR}
C {devices/lab_pin.sym} 350 -170 0 0 {name=p38
sig_type=std_logic
lab=VAPWR}
C {devices/lab_pin.sym} 310 170 0 0 {name=p39
sig_type=std_logic
lab=VGND}
C {devices/lab_pin.sym} 540 0 0 1 {name=p40
sig_type=std_logic
lab=ua[0]}
C {devices/lab_pin.sym} 540 40 0 1 {name=p41
sig_type=std_logic
lab=ua[1]}
C {devices/lab_pin.sym} 540 80 0 1 {name=p42
sig_type=std_logic
lab=ua[2]}
C {devices/lab_pin.sym} 540 -80 0 1 {name=p43
sig_type=std_logic
lab=ua[3]}
C {devices/lab_pin.sym} 540 -40 0 1 {name=p44
sig_type=std_logic
lab=ua[4]}
C {devices/lab_pin.sym} 260 120 0 0 {name=p45
sig_type=std_logic
lab=trim[7:0]}
